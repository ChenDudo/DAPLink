# Keil uVision project mm32link_mini_winusb_if.uvprojx, settings and files
target mm32link_mini_winusb_if (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F3273G6P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.6
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mm32link_mini_winusb_if
  BeforeMake: ..\..\..\tools\pre_build_script.bat
  AfterMake: ..\..\..\tools\post_build_script.bat $L@L $KARM
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: OS_TICK_FREQ=100, INTERFACE_MM32F3270, MM32F3270, __packed=__packed, DAPLINK_NO_ASSERT_FILENAMES, OS_CLOCK=96000000, MM32LINK_MINI, HSE_FREQ=12000000, DAPLINK_HIC_ID=0x4D4D3270, DAPLINK_VERSION=220729, MSC_ENDPOINT, CDC_ENDPOINT, WEBUSB_INTERFACE, HID_ENDPOINT, BULK_ENDPOINT, WINUSB_INTERFACE, DRAG_N_DROP_SUPPORT, DAPLINK_IF, DAPLINK_BUILD_KEY=0x9B939E8F, HID_LED_DEF=GPIO_LED_ON, CDC_LED_DEF=GPIO_LED_ON, MSC_LED_DEF=GPIO_LED_ON, USE_LEGACY_CMSIS_RTOS, OS_TICK=10000
  c misc: --gnu --asm --interleave -g
  c include: ..\..\..\source\hic_hal\mm32\mm32f3270; ..\..\..\source\hic_hal\mm32\mm32f3270\cmsis; ..\..\..\source\hic_hal\mm32\mm32f3270\hal; ..\..\..\source\hic_hal\mm32\mm32f3270\hal\Inc; ..\..\..\source\usb; ..\..\..\source\daplink\cmsis-dap; ..\..\..\source\daplink\drag-n-drop; ..\..\..\source\daplink\usb2uart; ..\..\..\source\daplink\settings; ..\..\..\source\daplink; ..\..\..\source\daplink\interface; ..\..\..\source\cmsis-core; ..\..\..\source\hic_hal; ..\..\..\source\hic_hal\cmsis-driver; ..\..\..\source\target; ..\..\..\source\rtos
  asm misc: --cpreproc --cpreproc_opts=-DOS_TICK_FREQ=100,-DINTERFACE_MM32F3270,-DMM32F3270,-D__packed=__packed,-DDAPLINK_NO_ASSERT_FILENAMES,-DOS_CLOCK=96000000,-DMM32LINK_MINI,-DHSE_FREQ=12000000,-DDAPLINK_HIC_ID=0x4D4D3270,-DDAPLINK_VERSION=220729,-DMSC_ENDPOINT,-DCDC_ENDPOINT,-DWEBUSB_INTERFACE,-DHID_ENDPOINT,-DBULK_ENDPOINT,-DWINUSB_INTERFACE,-DDRAG_N_DROP_SUPPORT,-DDAPLINK_IF,-DDAPLINK_BUILD_KEY=0x9B939E8F,-DHID_LED_DEF=GPIO_LED_ON,-DCDC_LED_DEF=GPIO_LED_ON,-DMSC_LED_DEF=GPIO_LED_ON,-DUSE_LEGACY_CMSIS_RTOS,-DOS_TICK=10000 -g
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\source\daplink\daplink.sct
  link misc: --bestdebug --predefine="-I..\..\..\source\hic_hal\mm32\mm32f3270" --predefine=-DDAPLINK_IF
  group board
    ../../../source/board/: mm32link_board.c
  group cmsis-dap
    ../../../source/daplink/cmsis-dap/: DAP.c DAP_queue.c DAP_UART.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
  group daplink_if
    ../../../source/daplink/interface/: bootloader_update.c daplink.c main_interface.c swd_host.c swd_host_ca.c target_flash.c
    ../../../source/daplink/: circ_buf.c cortex_m.c crc32.c daplink_debug.c error.c flash_hal.c HardFault_Handler.c info.c sdk_stub.c util.c validation.c
  group default
    ../../../source/hic_hal/mm32/mm32f3270/: beep.h DAP_config.h daplink_addr.h IO_Config.h USART_mm32f3270.h usbreg.h
    ../../../source/daplink/: bootloader.h circ_buf.h compiler.h cortex_m.h crc.h daplink.h daplink_debug.h daplink_defaults.h error.h info.h RTE_Components.h util.h validation.h version_git.h
    ../../../source/cmsis-core/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../../../source/rtos/: cmsis_os2.h rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Mutex.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h RTL.h RTX_Config.h
    ../../../source/daplink/cmsis-dap/: DAP.h DAP_queue.h dap_strings.h daplink_vendor_commands.h debug_ca.h debug_cm.h
    ../../../source/hic_hal/: device.h flash_blob.h flash_hal.h FlashOS.h FlashPrg.h gpio.h read_uid.h sdk.h uart.h
    ../../../source/hic_hal/cmsis-driver/: Driver_Common.h Driver_USART.h
    ../../../source/hic_hal/mm32/mm32f3270/hal/Inc/: dtype.h hal_adc.h hal_bkp.h hal_can.h hal_comp.h hal_conf.h hal_crc.h hal_crs.h hal_dac.h hal_dbg.h hal_device.h hal_dma.h hal_eth.h hal_eth_conf.h hal_exti.h hal_flash.h hal_fsmc.h hal_gpio.h hal_i2c.h hal_iwdg.h hal_misc.h hal_pwr.h hal_rcc.h hal_redefine.h hal_rtc.h hal_sdio.h hal_spi.h hal_syscfg.h hal_tim.h hal_uart.h hal_uid.h hal_ver.h hal_wwdg.h
    ../../../source/daplink/drag-n-drop/: file_stream.h flash_decoder.h flash_intf.h flash_manager.h intelhex.h vfs_manager.h vfs_user.h virtual_fs.h
    ../../../source/daplink/interface/: main_interface.h swd_host.h tasks.h
    ../../../source/hic_hal/mm32/mm32f3270/cmsis/: mm32_device.h mm32_reg.h mm32_reg_redefine_v1.h reg_adc.h reg_bkp.h reg_can.h reg_common.h reg_comp.h reg_crc.h reg_crs.h reg_dac.h reg_dbg.h reg_dma.h reg_eth.h reg_exti.h reg_flash.h reg_fsmc.h reg_gpio.h reg_i2c.h reg_iwdg.h reg_pwm.h reg_pwr.h reg_rcc.h reg_rtc.h reg_sdio.h reg_spi.h reg_syscfg.h reg_tim.h reg_uart.h reg_usb_otg_fs.h reg_wwdg.h types.h
    ../../../source/usb/: rl_usb.h usb.h usb_bulk.h usb_cdc.h usb_def.h usb_for_lib.h usb_hid.h usb_lib.h usb_msc.h usb_webusb.h usb_winusb.h usbd_cdc.h usbd_cdc_acm.h usbd_core.h usbd_core_cdc.h usbd_core_hid.h usbd_core_msc.h usbd_core_webusb.h usbd_core_winusb.h usbd_desc.h usbd_event.h usbd_hid.h usbd_hw.h usbd_lib_cdc.h usbd_lib_hid.h usbd_lib_msc.h usbd_msc.h
    ../../../source/daplink/settings/: settings.h
    ../../../source/target/: target_board.h target_config.h target_family.h
  group drag-n-drop
    ../../../source/daplink/drag-n-drop/: file_stream.c flash_decoder.c flash_intf.c flash_manager.c iap_flash_intf.c intelhex.c vfs_manager.c vfs_user.c virtual_fs.c
  group family
    ../../../source/family/mindmotion/mm32f3270/: target.c
    ../../../source/family/mindmotion/: target_reset.c
  group hic_hal
    ../../../source/hic_hal/mm32/mm32f3270/: beep.c flash.c gpio.c read_uid.c sdk.c uart.c USART_mm32f3270.c usb_config.c usbd_mm32F3270.c
    ../../../source/hic_hal/mm32/mm32f3270/hal/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
    ../../../source/hic_hal/mm32/mm32f3270/armcc/: startup_mm32f3270_armcc.s
    ../../../source/hic_hal/mm32/mm32f3270/cmsis/: system_mm32f327x.c
  group rtos
    ../../../source/rtos/: cmsis_os2_port.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c RTX_Config.c
    ../../../source/rtos/cm3/: HAL_CM3.c
    ../../../source/rtos/ARM/: SVC_Table.s
  group settings
    ../../../source/daplink/settings/: settings.c settings_rom.c
  group target
    ../../../source/target/: target_board.c target_default.c target_family.c
  group usb
    ../../../source/usb/bulk/: usbd_bulk.c
    ../../../source/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../../source/usb/: usbd_core.c
    ../../../source/usb/hid/: usbd_core_hid.c usbd_hid.c usbd_user_hid.c
    ../../../source/usb/msc/: usbd_core_msc.c usbd_msc.c
    ../../../source/usb/webusb/: usbd_core_webusb.c
    ../../../source/usb/winusb/: usbd_core_winusb.c
  group usb2uart
    ../../../source/daplink/usb2uart/: usbd_user_cdc_acm.c
